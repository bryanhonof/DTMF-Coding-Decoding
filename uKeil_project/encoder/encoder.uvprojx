# Keil uVision project encoder.uvprojx, settings and files
target S6ECC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.5.1
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: encoder
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\common\drivers;..\common\RTE\Device\S6E2CCAJ0A;.\inc
  memory RVCT4: ROM 0x0 size 0x300000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group src
    ./src/: main.c
  group drivers
    ../common/drivers/: audio.c delay.c dstc.c gpio.c i2c.c i2s.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, Device:Startup 1.0.0
